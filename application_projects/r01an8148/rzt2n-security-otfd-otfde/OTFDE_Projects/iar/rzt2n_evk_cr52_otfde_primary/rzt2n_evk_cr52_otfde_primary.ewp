# IAR project rzt2n_evk_cr52_otfde_primary.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G076M48_R52_0 Renesas R9A07G076M48_R52_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  ILINK.IlinkOutputFile: rzt2n_evk_cr52_otfde_primary.out
  ILINK.IlinkIcfFile: script/fsp_ram_execution.icf
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    rz_cfg/fsp_cfg/bsp/: board_cfg.h bsp_address_expander_cfg.h bsp_cfg.h bsp_mcu_cpu_memory_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_memory_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_mcu_secure_cfg.h bsp_mcu_tzc400_memory_cfg.h bsp_memory_cfg.h bsp_pin_cfg.h rz_bsp_cfg.h
    rz_cfg/fsp_cfg/: r_dmac_cfg.h r_gpt_cfg.h r_icu_inter_cpu_irq_cfg.h r_ioport_cfg.h r_rsip_cfg.h r_sci_uart_cfg.h
  group Flex Software/Components/arm
    rz/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    rz/arm/CMSIS_6/: LICENSE
  group Flex Software/Components/board
    rz/board/rzt2n_evb/: board.h board_ddr_param.c board_ddr_param.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
  group Flex Software/Components/fsp
    rz/fsp/src/bsp/mcu/all/: bsp_address_expander.c bsp_address_expander.h bsp_cache.c bsp_cache.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mbr_param.c bsp_mcu_api.h bsp_module_stop.h bsp_otfde.c bsp_otfde.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_sdhi.c bsp_sdhi.h bsp_semaphore.c bsp_semaphore.h bsp_slave_stop.c bsp_slave_stop.h bsp_tfu.h bsp_tzc400.c bsp_tzc400.h
    rz/fsp/inc/api/: bsp_api.h fsp_common_api.h r_icu_inter_cpu_irq_api.h r_ioport_api.h r_rsip_api.h r_timer_api.h r_transfer_api.h r_uart_api.h
    rz/fsp/src/bsp/mcu/all/cr/: bsp_cache_core.c bsp_cache_core.h bsp_delay_core.c bsp_delay_core.h bsp_irq_core.c bsp_irq_core.h bsp_mpu_core.c bsp_mpu_core.h
    rz/fsp/src/bsp/mcu/rzt2n/: bsp_ddr.c bsp_ddr.h bsp_elc.h bsp_feature.h bsp_irq_sense.c bsp_loader_param.c bsp_mcu_info.h bsp_override.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/: cmsis_compiler_rz.h R9A07G074.h R9A07G075.h R9A07G075M29.h R9A07G076.h R9A09G077.h renesas.h system.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/cr/: cmsis_cp15.h cmsis_iccarm.h core_cr52.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/cr/r-profile/: cmsis_iccarm_r.h
    rz/fsp/inc/: fsp_features.h fsp_version.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/inc/: iodefine.h r_error_codes.h r_typedefs.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/rsip/src/: r_cip_drv_api.c rsip_check_param.c rsip_check_param.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/rsip/inc/: r_cip_drv_api.h r_cip_drv_api_ext.h
    rz/fsp/src/r_dmac/: r_dmac.c
    rz/fsp/inc/instances/: r_dmac.h r_gpt.h r_icu_inter_cpu_irq.h r_ioport.h r_rsip.h r_sci_uart.h
    rz/fsp/src/r_gpt/: r_gpt.c
    rz/fsp/src/r_icu_inter_cpu_irq/: r_icu_inter_cpu_irq.c
    rz/fsp/src/r_ioport/: r_ioport.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/otp/src/: r_otp_drv.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/otp/inc/: r_otp_drv.h
    rz/fsp/src/r_rsip_protected/src/common/public/: r_rsip.c r_rsip_aes.c r_rsip_chacha.c r_rsip_ecc.c r_rsip_kdf.c r_rsip_otf.c r_rsip_pki.c r_rsip_public.h r_rsip_rsa.c r_rsip_sha.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/primitive/: r_rsip_addr.h r_rsip_primitive.c r_rsip_primitive.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/primitive/rzt2n/: r_rsip_data.c r_rsip_func008.c r_rsip_func016.c r_rsip_func017.c r_rsip_func022.c r_rsip_func023.c r_rsip_func027.c r_rsip_func028.c r_rsip_func030.c r_rsip_func040.c r_rsip_func041.c r_rsip_func043.c r_rsip_func044.c r_rsip_func045.c r_rsip_func046.c r_rsip_func047.c r_rsip_func050.c r_rsip_func051.c r_rsip_func052.c r_rsip_func053.c r_rsip_func054.c r_rsip_func055.c r_rsip_func056.c r_rsip_func057.c r_rsip_func058.c r_rsip_func059.c r_rsip_func061.c r_rsip_func062.c r_rsip_func071.c r_rsip_func072.c r_rsip_func073.c r_rsip_func074.c r_rsip_func075.c r_rsip_func076.c r_rsip_func077.c r_rsip_func078.c r_rsip_func079.c r_rsip_func084.c r_rsip_func085.c r_rsip_func086.c r_rsip_func087.c r_rsip_func088.c r_rsip_func089.c r_rsip_func091.c r_rsip_func100.c r_rsip_func101.c r_rsip_func102.c r_rsip_func103.c r_rsip_func205.c r_rsip_func206.c r_rsip_func215.c r_rsip_func216.c r_rsip_func220.c r_rsip_func221.c r_rsip_func300.c r_rsip_func301.c r_rsip_func302.c r_rsip_func303.c r_rsip_func304.c r_rsip_func305.c r_rsip_func306.c r_rsip_func307.c r_rsip_func308.c r_rsip_func309.c r_rsip_func310.c r_rsip_func311.c r_rsip_func400.c r_rsip_func401.c r_rsip_func402.c r_rsip_func403.c r_rsip_func404.c r_rsip_func405.c r_rsip_func406.c r_rsip_func407.c r_rsip_func408.c r_rsip_func420.c r_rsip_func421.c r_rsip_func422.c r_rsip_func423.c r_rsip_func431.c r_rsip_func432.c r_rsip_func433.c r_rsip_func434.c r_rsip_func435.c r_rsip_func436.c r_rsip_func440.c r_rsip_func441.c r_rsip_func443.c r_rsip_func450.c r_rsip_func501.c r_rsip_p00.c r_rsip_p01.c r_rsip_p02.c r_rsip_p03.c r_rsip_p04.c r_rsip_p06.c r_rsip_p07.c r_rsip_p08.c r_rsip_p0b.c r_rsip_p0c.c r_rsip_p0d.c r_rsip_p0e.c r_rsip_p0f.c r_rsip_p10.c r_rsip_p11.c r_rsip_p12.c r_rsip_p13.c r_rsip_p15.c r_rsip_p16.c r_rsip_p17.c r_rsip_p18.c r_rsip_p19.c r_rsip_p1a.c r_rsip_p1b.c r_rsip_p1c.c r_rsip_p1d.c r_rsip_p1e.c r_rsip_p1f.c r_rsip_p20.c r_rsip_p21.c r_rsip_p24.c r_rsip_p25.c r_rsip_p29a.c r_rsip_p29f.c r_rsip_p29i.c r_rsip_p29t.c r_rsip_p29u.c r_rsip_p2a.c r_rsip_p2b.c r_rsip_p2c.c r_rsip_p2d.c r_rsip_p2e.c r_rsip_p32a.c r_rsip_p32f.c r_rsip_p32i.c r_rsip_p32t.c r_rsip_p32u.c r_rsip_p34a.c r_rsip_p34f.c r_rsip_p34i.c r_rsip_p34t.c r_rsip_p34u.c r_rsip_p36a.c r_rsip_p36f.c r_rsip_p36i.c r_rsip_p36t.c r_rsip_p36u.c r_rsip_p37.c r_rsip_p38.c r_rsip_p3a.c r_rsip_p3b.c r_rsip_p3c.c r_rsip_p3d.c r_rsip_p3e.c r_rsip_p3f.c r_rsip_p40.c r_rsip_p41f.c r_rsip_p41i.c r_rsip_p41u.c r_rsip_p42.c r_rsip_p43.c r_rsip_p44f.c r_rsip_p44i.c r_rsip_p44u.c r_rsip_p45.c r_rsip_p47f.c r_rsip_p47i.c r_rsip_p47u.c r_rsip_p48f.c r_rsip_p48i.c r_rsip_p48u.c r_rsip_p4a.c r_rsip_p4c.c r_rsip_p4d.c r_rsip_p4e.c r_rsip_p4f.c r_rsip_p50f.c r_rsip_p50i.c r_rsip_p50u.c r_rsip_p51f.c r_rsip_p51i.c r_rsip_p52f.c r_rsip_p52i.c r_rsip_p53.c r_rsip_p54.c r_rsip_p56.c r_rsip_p57.c r_rsip_p59.c r_rsip_p5e.c r_rsip_p5ff.c r_rsip_p5fi.c r_rsip_p60.c r_rsip_p62.c r_rsip_p63.c r_rsip_p6d.c r_rsip_p6e.c r_rsip_p6f.c r_rsip_p70f.c r_rsip_p70i.c r_rsip_p70r.c r_rsip_p70s.c r_rsip_p70u.c r_rsip_p75f.c r_rsip_p75i.c r_rsip_p75r.c r_rsip_p75s.c r_rsip_p75u.c r_rsip_p79.c r_rsip_p7a.c r_rsip_p7b.c r_rsip_p7c.c r_rsip_p7d.c r_rsip_p7e.c r_rsip_p7f.c r_rsip_p80.c r_rsip_p83a.c r_rsip_p83f.c r_rsip_p83i.c r_rsip_p83t.c r_rsip_p83u.c r_rsip_p84.c r_rsip_p85a.c r_rsip_p85f.c r_rsip_p85i.c r_rsip_p85t.c r_rsip_p85u.c r_rsip_p86.c r_rsip_p87f.c r_rsip_p87i.c r_rsip_p87u.c r_rsip_p88.c r_rsip_p89f.c r_rsip_p89i.c r_rsip_p89u.c r_rsip_p8a.c r_rsip_p8b.c r_rsip_p8c.c r_rsip_p8d.c r_rsip_p8f.c r_rsip_p90.c r_rsip_p92.c r_rsip_p93.c r_rsip_p95f.c r_rsip_p95i.c r_rsip_p95u.c r_rsip_p98f.c r_rsip_p98i.c r_rsip_p98u.c r_rsip_p9d.c r_rsip_p9e.c r_rsip_p9f.c r_rsip_pa1f.c r_rsip_pa1i.c r_rsip_pa1u.c r_rsip_pa4f.c r_rsip_pa4i.c r_rsip_pa4u.c r_rsip_pa7f.c r_rsip_pa7i.c r_rsip_pa7u.c r_rsip_pa8.c r_rsip_pa9.c r_rsip_paa.c r_rsip_pab.c r_rsip_pb0f.c r_rsip_pb0i.c r_rsip_pb0u.c r_rsip_pb1.c r_rsip_pb2.c r_rsip_pb3f.c r_rsip_pb3i.c r_rsip_pb3u.c r_rsip_pb6f.c r_rsip_pb6i.c r_rsip_pb6u.c r_rsip_pb9f.c r_rsip_pb9i.c r_rsip_pb9u.c r_rsip_pba.c r_rsip_pbc.c r_rsip_pc2f.c r_rsip_pc2i.c r_rsip_pc2u.c r_rsip_pe0.c r_rsip_pe1.c r_rsip_pe2.c r_rsip_pe3.c r_rsip_pe4.c r_rsip_pe5e.c r_rsip_pe5f.c r_rsip_pe5i.c r_rsip_pe5r.c r_rsip_pe5s.c r_rsip_pe5u.c r_rsip_pe6.c r_rsip_pe7.c r_rsip_pe8.c r_rsip_pe9.c r_rsip_pea.c r_rsip_peb.c r_rsip_pec.c r_rsip_pedf.c r_rsip_pedi.c r_rsip_peef.c r_rsip_peei.c r_rsip_pf0.c r_rsip_pf1.c r_rsip_pf3.c r_rsip_pf4.c r_rsip_pf5.c r_rsip_pf6.c r_rsip_pf7.c r_rsip_pf8.c r_rsip_pf9.c r_rsip_pfa.c r_rsip_pfb.c r_rsip_pfc.c
    rz/fsp/src/r_rsip_protected/src/common/primitive/: r_rsip_err.h r_rsip_reg.c r_rsip_reg.h r_rsip_util.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/: r_rsip_hal.c r_rsip_otp.c r_rsip_otp.h r_rsip_wrapper.c r_rsip_wrapper.h
    rz/fsp/src/r_rsip_protected/src/common/private/: r_rsip_private.c r_rsip_private.h r_rsip_private_sub1.c r_rsip_private_sub2.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/public/: r_rsip_rzt_rzn.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/sb_lib/src/: r_sb_api.c r_sb_build_config.h r_sb_cmn.c r_sb_cmn.h r_sb_cmn_drv.c r_sb_cmn_drv.h r_sb_manifest.c r_sb_manifest.h r_sb_sb.c r_sb_sb.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/sb_lib/inc/: r_sb_api.h
    rz/fsp/src/r_sci_uart/: r_sci_uart.c
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c system_core.c
  group Flex Software/Generated Data
    rz_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c otfde_data.c otfde_sample.h otfde_sample_cr52.c
