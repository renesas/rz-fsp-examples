<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rzt2n_evk_cr52_otfde_primary.ewp</path>
    </project>
    <batchBuild/>
</workspace>
