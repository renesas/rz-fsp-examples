<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rzt2n_evk_ca55_otfd_xspi_boot.ewp</path>
    </project>
    <batchBuild/>
</workspace>
