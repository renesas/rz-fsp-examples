<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rz_arm_dsp_examples_rzt2n_evk.ewp</path>
    </project>
    <batchBuild/>
</workspace>
