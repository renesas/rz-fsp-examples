# IAR project rzt2n_evk_cr52_lwip_mbedtls.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G076M48_R52_0 Renesas R9A07G076M48_R52_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _LWIP_ADD_ON_APP=0; USER_PROGRAM_LOCATION=2
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCIncludePath2: ..\..\common\oss\lwip\src\include; ..\..\common\renesas\module\lwip_port\lwip_osal\include; ..\..\common\renesas\oss_deps\lwip; ..\..\common\renesas\module\ether_netif; ..\..\common\renesas\module\lwip_port; ..\..\common\renesas\module\serial_io; ..\..\common\renesas\module; ..\..\common\renesas\application; ..\..\common\oss\mbedtls\include\mbedtls; ..\..\common\oss\mbedtls\include; ..\..\common\oss\mbedtls\include\psa; ..\..\common\oss\mbedtls\library; ..\..\common\renesas\module\mbedtls_port\include; ..\..\common\renesas\module\mbedtls_port\library; ..\..\common\renesas\module\mbedtls_port\include\mbedtls; ..\..\common\renesas\module\mbedtls_port\include\psa; ..\..\common\renesas\oss_deps\mbedtls_drv
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  OBJCOPY.OOCOutputFile: rzt2n_evk_cr52_lwip_mbedtls.srec
  ILINK.IlinkOutputFile: rzt2n_evk_cr52_lwip_mbedtls.out
  ILINK.IlinkConfigDefines: USER_PROGRAM_LOCATION=2
  ILINK.IlinkIcfFile: script/fsp_ram_execution.icf
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group common/oss/lwip/src/api
    ../../common/oss/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group common/oss/lwip/src/apps/lwiperf
    ../../common/oss/lwip/src/apps/lwiperf/: lwiperf.c
  group common/oss/lwip/src/apps/sntp
    ../../common/oss/lwip/src/apps/sntp/: sntp.c
  group common/oss/lwip/src/core
    ../../common/oss/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group common/oss/lwip/src/core/ipv4
    ../../common/oss/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group common/oss/lwip/src/netif
    ../../common/oss/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group common/oss/lwip/src/netif/ppp
    ../../common/oss/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group common/oss/lwip/src/netif/ppp/polarssl
    ../../common/oss/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group common/oss/mbedtls/include/mbedtls
    ../../common/oss/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h sha1.h sha256.h sha3.h sha512.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group common/oss/mbedtls/include/psa
    ../../common/oss/mbedtls/include/psa/: build_info.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_types.h crypto_values.h
  group common/oss/mbedtls/library
    ../../common/oss/mbedtls/library/: aes.c aesce.c aesce.h aesni.c aesni.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.c bignum_core.h bignum_core_invasive.h bignum_internal.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_invasive.h cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr.h ctr_drbg.c debug.c debug_internal.h des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md5.c md_psa.h md_wrap.h memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_internal.h pk_wrap.h pkcs12.c pkcs5.c pkcs7.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_ffdh.c psa_crypto_ffdh.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_pake.c psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c psa_util.c psa_util_internal.h ripemd160.c rsa_alt_helpers.c rsa_alt_helpers.h rsa_internal.h sha1.c sha256.c sha3.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_ciphersuites_internal.h ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_ticket.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_csr.c x509_internal.h x509write.c x509write_crt.c x509write_csr.c
  group common/renesas/application
    ../../common/renesas/application/: certs.c certs.h lwip_port_instance.c threading_alt.h tlsapp_mbedtls.c tlsapp_mbedtls.h tlsapp_mbedtls_config.h tlsapp_mbedtls_lwip_main.c tlsapp_mbedtls_sockets.h
  group common/renesas/module
    ../../common/renesas/module/: um_common.h
  group common/renesas/module/ether_netif
    ../../common/renesas/module/ether_netif/: um_ether_netif.c um_ether_netif.h um_ether_netif_api.h um_ether_netif_callback.c um_ether_netif_cfg.h um_ether_netif_ether.c um_ether_netif_feature.h um_ether_netif_internal.h um_ether_netif_task_monitor.c um_ether_netif_task_reader.c um_ether_netif_task_writer.c
  group common/renesas/module/lwip_port
    ../../common/renesas/module/lwip_port/: um_lwip_port.c um_lwip_port.h um_lwip_port_api.h um_lwip_port_callback.c um_lwip_port_cfg.h um_lwip_port_core.c um_lwip_port_ether_netif.c um_lwip_port_internal.h um_lwip_port_netif.c um_lwip_port_netif_list.c um_lwip_port_task_launcher.c
  group common/renesas/module/lwip_port/lwip_osal/include
    ../../common/renesas/module/lwip_port/lwip_osal/include/: lwipopts_freertos.h
  group common/renesas/module/lwip_port/lwip_osal/include/arch
    ../../common/renesas/module/lwip_port/lwip_osal/include/arch/: cc.h perf.h sys_arch.h
  group common/renesas/module/lwip_port/lwip_osal/src
    ../../common/renesas/module/lwip_port/lwip_osal/src/: sys_arch.c
  group common/renesas/module/mbedtls_port/include/mbedtls
    ../../common/renesas/module/mbedtls_port/include/mbedtls/: ecp.h mbedtls_config.h pk.h rsa.h ssl.h
  group common/renesas/module/mbedtls_port/include/psa
    ../../common/renesas/module/mbedtls_port/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_sizes.h crypto_struct.h
  group common/renesas/module/mbedtls_port/library
    ../../common/renesas/module/mbedtls_port/library/: alignment.h ecp.c pk_ecc.c pk_wrap.c psa_crypto.c psa_crypto_driver_wrappers.h psa_crypto_driver_wrappers_no_static.c rsa.c ssl_misc.h ssl_msg.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c x509_crt.c
  group common/renesas/module/serial_io
    ../../common/renesas/module/serial_io/: um_serial_io_api.h um_serial_io_uart.c
  group common/renesas/oss_deps/lwip
    ../../common/renesas/oss_deps/lwip/: lwipopts.h lwippools.h
  group common/renesas/oss_deps/mbedtls_drv
    ../../common/renesas/oss_deps/mbedtls_drv/: tlsapp_mbedtls_hwacc_drv.c tlsapp_mbedtls_hwacc_drv.h tlsapp_mbedtls_hwacc_drv_types.h
  group Flex Software/Build Configuration
    rz_cfg/fsp_cfg/bsp/: board_cfg.h bsp_address_expander_cfg.h bsp_cfg.h bsp_mcu_cpu_memory_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_memory_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_mcu_secure_cfg.h bsp_mcu_tzc400_memory_cfg.h bsp_memory_cfg.h bsp_pin_cfg.h rz_bsp_cfg.h
    rz_cfg/aws/: FreeRTOSConfig.h
    rz_cfg/fsp_cfg/: r_ether_cfg.h r_ether_phy_cfg.h r_ether_selector_cfg.h r_ether_switch_cfg.h r_ioport_cfg.h r_rsip_cfg.h r_sci_uart_cfg.h
    rz_cfg/driver/: r_xspi_qspi_cfg.h
  group Flex Software/Components/arm
    rz/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    rz/arm/CMSIS_6/: LICENSE
  group Flex Software/Components/aws
    rz/aws/FreeRTOS-Kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    rz/aws/FreeRTOS-Kernel/: event_groups.c LICENSE.md list.c queue.c stream_buffer.c tasks.c timers.c
    rz/aws/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group Flex Software/Components/board
    rz/board/rzt2n_evb/: board.h board_ddr_param.c board_ddr_param.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
  group Flex Software/Components/fsp
    rz/fsp/src/bsp/mcu/all/: bsp_address_expander.c bsp_address_expander.h bsp_cache.c bsp_cache.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mbr_param.c bsp_mcu_api.h bsp_module_stop.h bsp_otfde.c bsp_otfde.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_sdhi.c bsp_sdhi.h bsp_semaphore.c bsp_semaphore.h bsp_slave_stop.c bsp_slave_stop.h bsp_tfu.h bsp_tzc400.c bsp_tzc400.h
    rz/fsp/inc/api/: bsp_api.h fsp_common_api.h r_ether_api.h r_ether_phy_api.h r_ether_selector_api.h r_ether_switch_api.h r_ioport_api.h r_rsip_api.h r_spi_flash_api.h r_transfer_api.h r_uart_api.h
    rz/fsp/src/bsp/mcu/all/cr/: bsp_cache_core.c bsp_cache_core.h bsp_delay_core.c bsp_delay_core.h bsp_irq_core.c bsp_irq_core.h bsp_mpu_core.c bsp_mpu_core.h
    rz/fsp/src/bsp/mcu/rzt2n/: bsp_ddr.c bsp_ddr.h bsp_elc.h bsp_feature.h bsp_irq_sense.c bsp_loader_param.c bsp_mcu_info.h bsp_override.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/: cmsis_compiler_rz.h R9A07G074.h R9A07G075.h R9A07G075M29.h R9A07G076.h R9A09G077.h renesas.h system.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/cr/: cmsis_cp15.h cmsis_iccarm.h core_cr52.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/cr/r-profile/: cmsis_iccarm_r.h
    rz/fsp/inc/: fsp_features.h fsp_version.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/inc/: iodefine.h r_error_codes.h r_typedefs.h
    rz/fsp/src/rm_freertos_port/cr52/: port.c portmacro_cr52.h
    rz/fsp/src/rm_freertos_port/: portmacro.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/rsip/src/: r_cip_drv_api.c rsip_check_param.c rsip_check_param.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/rsip/inc/: r_cip_drv_api.h r_cip_drv_api_ext.h
    rz/fsp/src/r_ether_phy/: r_ether_phy.c
    rz/fsp/inc/instances/: r_ether_phy.h r_ether_selector.h r_ethsw.h r_gmac_b.h r_ioport.h r_rsip.h r_sci_uart.h r_xspi_qspi.h
    rz/fsp/src/r_ether_selector/: r_ether_selector.c
    rz/fsp/src/r_ethsw/: r_ethsw.c
    rz/fsp/src/r_gmac_b/: r_gmac_b.c
    rz/fsp/src/r_ioport/: r_ioport.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/otp/src/: r_otp_drv.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/otp/inc/: r_otp_drv.h
    rz/fsp/src/r_rsip_protected/src/common/public/: r_rsip.c r_rsip_aes.c r_rsip_chacha.c r_rsip_ecc.c r_rsip_kdf.c r_rsip_otf.c r_rsip_pki.c r_rsip_public.h r_rsip_rsa.c r_rsip_sha.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/primitive/: r_rsip_addr.h r_rsip_primitive.c r_rsip_primitive.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/primitive/rzt2n/: r_rsip_data.c r_rsip_func008.c r_rsip_func016.c r_rsip_func017.c r_rsip_func022.c r_rsip_func023.c r_rsip_func027.c r_rsip_func028.c r_rsip_func030.c r_rsip_func040.c r_rsip_func041.c r_rsip_func043.c r_rsip_func044.c r_rsip_func045.c r_rsip_func046.c r_rsip_func047.c r_rsip_func050.c r_rsip_func051.c r_rsip_func052.c r_rsip_func053.c r_rsip_func054.c r_rsip_func055.c r_rsip_func056.c r_rsip_func057.c r_rsip_func058.c r_rsip_func059.c r_rsip_func061.c r_rsip_func062.c r_rsip_func071.c r_rsip_func072.c r_rsip_func073.c r_rsip_func074.c r_rsip_func075.c r_rsip_func076.c r_rsip_func077.c r_rsip_func078.c r_rsip_func079.c r_rsip_func084.c r_rsip_func085.c r_rsip_func086.c r_rsip_func087.c r_rsip_func088.c r_rsip_func089.c r_rsip_func091.c r_rsip_func100.c r_rsip_func101.c r_rsip_func102.c r_rsip_func103.c r_rsip_func205.c r_rsip_func206.c r_rsip_func215.c r_rsip_func216.c r_rsip_func220.c r_rsip_func221.c r_rsip_func300.c r_rsip_func301.c r_rsip_func302.c r_rsip_func303.c r_rsip_func304.c r_rsip_func305.c r_rsip_func306.c r_rsip_func307.c r_rsip_func308.c r_rsip_func309.c r_rsip_func310.c r_rsip_func311.c r_rsip_func400.c r_rsip_func401.c r_rsip_func402.c r_rsip_func403.c r_rsip_func404.c r_rsip_func405.c r_rsip_func406.c r_rsip_func407.c r_rsip_func408.c r_rsip_func420.c r_rsip_func421.c r_rsip_func422.c r_rsip_func423.c r_rsip_func431.c r_rsip_func432.c r_rsip_func433.c r_rsip_func434.c r_rsip_func435.c r_rsip_func436.c r_rsip_func440.c r_rsip_func441.c r_rsip_func443.c r_rsip_func450.c r_rsip_func501.c r_rsip_p00.c r_rsip_p01.c r_rsip_p02.c r_rsip_p03.c r_rsip_p04.c r_rsip_p06.c r_rsip_p07.c r_rsip_p08.c r_rsip_p0b.c r_rsip_p0c.c r_rsip_p0d.c r_rsip_p0e.c r_rsip_p0f.c r_rsip_p10.c r_rsip_p11.c r_rsip_p12.c r_rsip_p13.c r_rsip_p15.c r_rsip_p16.c r_rsip_p17.c r_rsip_p18.c r_rsip_p19.c r_rsip_p1a.c r_rsip_p1b.c r_rsip_p1c.c r_rsip_p1d.c r_rsip_p1e.c r_rsip_p1f.c r_rsip_p20.c r_rsip_p21.c r_rsip_p24.c r_rsip_p25.c r_rsip_p29a.c r_rsip_p29f.c r_rsip_p29i.c r_rsip_p29t.c r_rsip_p29u.c r_rsip_p2a.c r_rsip_p2b.c r_rsip_p2c.c r_rsip_p2d.c r_rsip_p2e.c r_rsip_p32a.c r_rsip_p32f.c r_rsip_p32i.c r_rsip_p32t.c r_rsip_p32u.c r_rsip_p34a.c r_rsip_p34f.c r_rsip_p34i.c r_rsip_p34t.c r_rsip_p34u.c r_rsip_p36a.c r_rsip_p36f.c r_rsip_p36i.c r_rsip_p36t.c r_rsip_p36u.c r_rsip_p37.c r_rsip_p38.c r_rsip_p3a.c r_rsip_p3b.c r_rsip_p3c.c r_rsip_p3d.c r_rsip_p3e.c r_rsip_p3f.c r_rsip_p40.c r_rsip_p41f.c r_rsip_p41i.c r_rsip_p41u.c r_rsip_p42.c r_rsip_p43.c r_rsip_p44f.c r_rsip_p44i.c r_rsip_p44u.c r_rsip_p45.c r_rsip_p47f.c r_rsip_p47i.c r_rsip_p47u.c r_rsip_p48f.c r_rsip_p48i.c r_rsip_p48u.c r_rsip_p4a.c r_rsip_p4c.c r_rsip_p4d.c r_rsip_p4e.c r_rsip_p4f.c r_rsip_p50f.c r_rsip_p50i.c r_rsip_p50u.c r_rsip_p51f.c r_rsip_p51i.c r_rsip_p52f.c r_rsip_p52i.c r_rsip_p53.c r_rsip_p54.c r_rsip_p56.c r_rsip_p57.c r_rsip_p59.c r_rsip_p5e.c r_rsip_p5ff.c r_rsip_p5fi.c r_rsip_p60.c r_rsip_p62.c r_rsip_p63.c r_rsip_p6d.c r_rsip_p6e.c r_rsip_p6f.c r_rsip_p70f.c r_rsip_p70i.c r_rsip_p70r.c r_rsip_p70s.c r_rsip_p70u.c r_rsip_p75f.c r_rsip_p75i.c r_rsip_p75r.c r_rsip_p75s.c r_rsip_p75u.c r_rsip_p79.c r_rsip_p7a.c r_rsip_p7b.c r_rsip_p7c.c r_rsip_p7d.c r_rsip_p7e.c r_rsip_p7f.c r_rsip_p80.c r_rsip_p83a.c r_rsip_p83f.c r_rsip_p83i.c r_rsip_p83t.c r_rsip_p83u.c r_rsip_p84.c r_rsip_p85a.c r_rsip_p85f.c r_rsip_p85i.c r_rsip_p85t.c r_rsip_p85u.c r_rsip_p86.c r_rsip_p87f.c r_rsip_p87i.c r_rsip_p87u.c r_rsip_p88.c r_rsip_p89f.c r_rsip_p89i.c r_rsip_p89u.c r_rsip_p8a.c r_rsip_p8b.c r_rsip_p8c.c r_rsip_p8d.c r_rsip_p8f.c r_rsip_p90.c r_rsip_p92.c r_rsip_p93.c r_rsip_p95f.c r_rsip_p95i.c r_rsip_p95u.c r_rsip_p98f.c r_rsip_p98i.c r_rsip_p98u.c r_rsip_p9d.c r_rsip_p9e.c r_rsip_p9f.c r_rsip_pa1f.c r_rsip_pa1i.c r_rsip_pa1u.c r_rsip_pa4f.c r_rsip_pa4i.c r_rsip_pa4u.c r_rsip_pa7f.c r_rsip_pa7i.c r_rsip_pa7u.c r_rsip_pa8.c r_rsip_pa9.c r_rsip_paa.c r_rsip_pab.c r_rsip_pb0f.c r_rsip_pb0i.c r_rsip_pb0u.c r_rsip_pb1.c r_rsip_pb2.c r_rsip_pb3f.c r_rsip_pb3i.c r_rsip_pb3u.c r_rsip_pb6f.c r_rsip_pb6i.c r_rsip_pb6u.c r_rsip_pb9f.c r_rsip_pb9i.c r_rsip_pb9u.c r_rsip_pba.c r_rsip_pbc.c r_rsip_pc2f.c r_rsip_pc2i.c r_rsip_pc2u.c r_rsip_pe0.c r_rsip_pe1.c r_rsip_pe2.c r_rsip_pe3.c r_rsip_pe4.c r_rsip_pe5e.c r_rsip_pe5f.c r_rsip_pe5i.c r_rsip_pe5r.c r_rsip_pe5s.c r_rsip_pe5u.c r_rsip_pe6.c r_rsip_pe7.c r_rsip_pe8.c r_rsip_pe9.c r_rsip_pea.c r_rsip_peb.c r_rsip_pec.c r_rsip_pedf.c r_rsip_pedi.c r_rsip_peef.c r_rsip_peei.c r_rsip_pf0.c r_rsip_pf1.c r_rsip_pf3.c r_rsip_pf4.c r_rsip_pf5.c r_rsip_pf6.c r_rsip_pf7.c r_rsip_pf8.c r_rsip_pf9.c r_rsip_pfa.c r_rsip_pfb.c r_rsip_pfc.c
    rz/fsp/src/r_rsip_protected/src/common/primitive/: r_rsip_err.h r_rsip_reg.c r_rsip_reg.h r_rsip_util.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/: r_rsip_hal.c r_rsip_otp.c r_rsip_otp.h r_rsip_wrapper.c r_rsip_wrapper.h
    rz/fsp/src/r_rsip_protected/src/common/private/: r_rsip_private.c r_rsip_private.h r_rsip_private_sub1.c r_rsip_private_sub2.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/public/: r_rsip_rzt_rzn.c
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/sb_lib/src/: r_sb_api.c r_sb_build_config.h r_sb_cmn.c r_sb_cmn.h r_sb_cmn_drv.c r_sb_cmn_drv.h r_sb_manifest.c r_sb_manifest.h r_sb_sb.c r_sb_sb.h
    rz/fsp/src/r_rsip_protected/src/rzt_rzn/private/lib/sb_lib/inc/: r_sb_api.h
    rz/fsp/src/r_sci_uart/: r_sci_uart.c
    rz/fsp/src/r_xspi_qspi/: r_xspi_qspi.c
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c system_core.c
  group Flex Software/Generated Data
    rz_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c main_thread.c main_thread.h pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c main_thread_entry.c
