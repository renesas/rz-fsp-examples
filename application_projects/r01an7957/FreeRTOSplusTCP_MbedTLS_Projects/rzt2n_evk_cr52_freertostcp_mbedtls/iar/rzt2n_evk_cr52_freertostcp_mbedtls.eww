<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rzt2n_evk_cr52_freertostcp_mbedtls.ewp</path>
    </project>
    <batchBuild/>
</workspace>
