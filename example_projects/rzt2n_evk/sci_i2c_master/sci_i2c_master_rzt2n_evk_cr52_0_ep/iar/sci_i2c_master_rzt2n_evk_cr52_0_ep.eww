<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\sci_i2c_master_rzt2n_evk_cr52_0_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
