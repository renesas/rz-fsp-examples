<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\ethernet_frer_rzt2n_evk_cr52_0_sender_ep.ewp</path>
    </project>
    <batchBuild/>
</workspace>
