# IAR project ethernet_L3_forwarding_rzt2n_evk_ca55_0_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G076M48_A55 Renesas R9A07G076M48_A55
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 69
  General.FPU2: 0
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  OBJCOPY.OOCOutputFile: ethernet_L3_forwarding_rzt2n_evk_ca55_0_ep.hex
  ILINK.IlinkOutputFile: ethernet_L3_forwarding_rzt2n_evk_ca55_0_ep.out
  ILINK.IlinkIcfFile: script/fsp_ram_execution.icf
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"; --redirect Reset_Handler=system_init
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 60
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    rz_cfg/fsp_cfg/bsp/: board_cfg.h bsp_address_expander_cfg.h bsp_cfg.h bsp_mcu_cpu_memory_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_memory_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_mcu_secure_cfg.h bsp_mcu_tzc400_memory_cfg.h bsp_memory_cfg.h bsp_pin_cfg.h rz_bsp_cfg.h
    rz_cfg/fsp_cfg/: r_ether_phy_cfg.h r_ether_selector_cfg.h r_gptp_cfg.h r_ioport_cfg.h r_layer3_switch_cfg.h r_rmac_cfg.h r_sci_uart_cfg.h
  group Flex Software/Components/arm
    rz/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: armv7a.h armv7a_cp15.h armv8a.h armv8a_cp15.h cmsis_armclang_a.h cmsis_clang_a.h cmsis_gcc_a.h cmsis_iccarm_a.h gicv2.h irq_ctrl.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: armv7r.h armv7r_cp15.h armv8r.h armv8r_cp15.h.h cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h cmsis_iccarm_r.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_ca.h core_ca35.h core_ca5.h core_ca53.h core_ca55.h core_ca57.h core_ca7.h core_ca9.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_cr4.h core_cr5.h core_cr52.h core_cr7.h core_cr8.h core_sc000.h core_sc300.h core_starmc1.h core_starmc3.h tz_context.h
    rz/arm/CMSIS_6/: LICENSE
  group Flex Software/Components/arm/r-profile
    rz/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: gicv2.h
  group Flex Software/Components/board
    rz/board/rzt2n_evb/: board.h board_ddr_param.c board_ddr_param.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
  group Flex Software/Components/fsp
    rz/fsp/src/bsp/mcu/all/: bsp_address_expander.c bsp_address_expander.h bsp_cache.c bsp_cache.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mbr_param.c bsp_mcu_api.h bsp_module_stop.h bsp_otfde.c bsp_otfde.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_sdhi.c bsp_sdhi.h bsp_semaphore.c bsp_semaphore.h bsp_slave_stop.c bsp_slave_stop.h bsp_tfu.h bsp_tzc400.c bsp_tzc400.h
    rz/fsp/inc/api/: bsp_api.h fsp_common_api.h r_ether_api.h r_ether_phy_api.h r_ether_selector_api.h r_ether_switch_api.h r_gptp_api.h r_ioport_api.h r_transfer_api.h r_uart_api.h
    rz/fsp/src/bsp/mcu/all/ca/: bsp_cache_core.c bsp_cache_core.h bsp_delay_core.c bsp_delay_core.h bsp_irq_core.c bsp_irq_core.h bsp_mmu_core.c bsp_mmu_core.h
    rz/fsp/src/bsp/mcu/rzt2n/: bsp_ddr.c bsp_ddr.h bsp_elc.h bsp_feature.h bsp_irq_sense.c bsp_loader_param.c bsp_mcu_info.h bsp_override.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/ca/: cmsis_compiler_64bit.h cmsis_cp15_64bit.h cmsis_gcc_64bit.h cmsis_iccarm_64bit.h core_ca55.h core_ca_64bit.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/: cmsis_compiler_rz.h R9A07G074.h R9A07G075.h R9A07G075M29.h R9A07G076.h R9A09G077.h renesas.h system.h
    rz/fsp/inc/: fsp_features.h fsp_version.h
    rz/fsp/src/r_ether_phy/: r_ether_phy.c
    rz/fsp/inc/instances/: r_ether_phy.h r_ether_selector.h r_gptp.h r_ioport.h r_layer3_switch.h r_rmac.h r_sci_uart.h
    rz/fsp/src/r_ether_selector/: r_ether_selector.c
    rz/fsp/src/r_gptp/: r_gptp.c
    rz/fsp/src/r_ioport/: r_ioport.c
    rz/fsp/src/r_layer3_switch/: r_layer3_switch.c
    rz/fsp/src/r_rmac/: r_rmac.c
    rz/fsp/src/r_sci_uart/: r_sci_uart.c
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Source/ca/: startup_core.c system_core.c
  group Flex Software/Generated Data
    rz_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: common_utils.h hal_entry.c L3forwarding.c L3forwarding.h sio_char.h siochar.c syscalls.c
