# IAR project usb_hmsc_rzt2n_evk_cr52_0_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G076M48_R52_0 Renesas R9A07G076M48_R52_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  OBJCOPY.OOCOutputFile: usb_hmsc_rzt2n_evk_cr52_0_ep.hex
  ILINK.IlinkOutputFile: usb_hmsc_rzt2n_evk_cr52_0_ep.out
  ILINK.IlinkIcfFile: script/fsp_ram_execution.icf
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"; --redirect Reset_Handler=system_init
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    rz_cfg/fsp_cfg/bsp/: board_cfg.h bsp_address_expander_cfg.h bsp_cfg.h bsp_mcu_cpu_memory_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_memory_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_mcu_secure_cfg.h bsp_mcu_tzc400_memory_cfg.h bsp_memory_cfg.h bsp_pin_cfg.h rz_bsp_cfg.h
    rz_cfg/freertos/: FreeRTOSFATConfig.h
    rz_cfg/fsp_cfg/: r_ioport_cfg.h r_sci_uart_cfg.h r_usb_basic_cfg.h r_usb_class_cfg.h
    rz_cfg/driver/: rm_block_media_usb_cfg.h
    rz_cfg/fsp_cfg/middleware/: rm_freertos_plus_fat_cfg.h
  group Flex Software/Components/arm
    rz/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    rz/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    rz/arm/CMSIS_6/: LICENSE
  group Flex Software/Components/aws
    rz/aws/FreeRTOS-Kernel/include/: atomic.h CMakeLists.txt croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group Flex Software/Components/board
    rz/board/rzt2n_evb/: board.h board_ddr_param.c board_ddr_param.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
  group Flex Software/Components/freertos
    rz/freertos/Lab-Project-FreeRTOS-FAT/: ff_crc.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c LICENSE.md
    rz/freertos/Lab-Project-FreeRTOS-FAT/include/: ff_crc.h ff_devices.h ff_dir.h ff_error.h ff_fat.h ff_fatdef.h ff_file.h ff_format.h ff_headers.h ff_ioman.h ff_locking.h ff_memory.h ff_old_config_defines.h ff_stdio.h ff_string.h ff_sys.h ff_time.h FreeRTOS_errno_FAT.h FreeRTOSFATConfigDefaults.h
  group Flex Software/Components/fsp
    rz/fsp/src/bsp/mcu/all/: bsp_address_expander.c bsp_address_expander.h bsp_cache.c bsp_cache.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mbr_param.c bsp_mcu_api.h bsp_module_stop.h bsp_otfde.c bsp_otfde.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_sdhi.c bsp_sdhi.h bsp_semaphore.c bsp_semaphore.h bsp_slave_stop.c bsp_slave_stop.h bsp_tfu.h bsp_tzc400.c bsp_tzc400.h
    rz/fsp/inc/api/: bsp_api.h fsp_common_api.h r_ioport_api.h r_transfer_api.h r_uart_api.h r_usb_basic_api.h r_usb_hmsc_api.h rm_block_media_api.h rm_freertos_plus_fat_api.h
    rz/fsp/src/bsp/mcu/all/cr/: bsp_cache_core.c bsp_cache_core.h bsp_delay_core.c bsp_delay_core.h bsp_irq_core.c bsp_irq_core.h bsp_mpu_core.c bsp_mpu_core.h
    rz/fsp/src/bsp/mcu/rzt2n/: bsp_ddr.c bsp_ddr.h bsp_elc.h bsp_feature.h bsp_irq_sense.c bsp_loader_param.c bsp_mcu_info.h bsp_override.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/: cmsis_compiler_rz.h R9A07G074.h R9A07G075.h R9A07G075M29.h R9A07G076.h R9A09G077.h renesas.h system.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/cr/: cmsis_cp15.h cmsis_iccarm.h core_cr52.h
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Include/cr/r-profile/: cmsis_iccarm_r.h
    rz/fsp/src/rm_freertos_plus_fat/: ff_locking.c FreeRTOSConfigMinimal.h rm_freertos_plus_fat.c
    rz/fsp/inc/: fsp_features.h fsp_version.h
    rz/fsp/src/rm_freertos_port/: portmacro.h
    rz/fsp/src/rm_freertos_port/cr52/: portmacro_cr52.h
    rz/fsp/src/r_ioport/: r_ioport.c
    rz/fsp/inc/instances/: r_ioport.h r_sci_uart.h r_usb_basic.h r_usb_hmsc.h rm_block_media_usb.h rm_freertos_plus_fat.h
    rz/fsp/src/r_sci_uart/: r_sci_uart.c
    rz/fsp/src/r_usb_basic/: r_usb_basic.c
    rz/fsp/src/r_usb_basic/src/driver/inc/: r_usb_basic_config.h r_usb_basic_define.h r_usb_basic_if.h r_usb_basic_local.h r_usb_cstd_rtos.h r_usb_extern.h r_usb_hehci_def_usr.h r_usb_hehci_extern.h r_usb_hehci_typedef.h r_usb_hhci.h r_usb_hhci_local.h r_usb_hohci_def_usr.h r_usb_hohci_extern.h r_usb_hohci_typedef.h r_usb_rtos_config.h r_usb_typedef.h
    rz/fsp/src/r_usb_basic/src/hw/inc/: r_usb_bitdefine.h r_usb_dmac.h r_usb_dmaca_rz_config.h r_usb_dmaca_rz_config_reference.h r_usb_dmaca_rz_if.h r_usb_dmaca_rz_private.h r_usb_dmaca_rz_target.h r_usb_reg_access.h
    rz/fsp/src/r_usb_basic/src/driver/: r_usb_cdataio.c r_usb_clibusbip.c r_usb_cstd_rtos.c r_usb_hbc.c r_usb_hdriver.c r_usb_hdriver_api_rz.c r_usb_hdriver_rz.c r_usb_hehci_main.c r_usb_hehci_memory.c r_usb_hehci_transfer.c r_usb_hhci.c r_usb_hhubsys.c r_usb_hintfifo.c r_usb_hinthandler_rz.c r_usb_hinthandler_usbip0.c r_usb_hinthandler_usbip1.c r_usb_hlibusbip.c r_usb_hmanager.c r_usb_hmanager_rz.c r_usb_hohci_main.c r_usb_hohci_memory.c r_usb_hohci_transfer.c r_usb_hscheduler.c r_usb_hscheduler_rz.c r_usb_hstdfunction.c r_usb_mmu_pa_to_va.c r_usb_pbc.c r_usb_pcontrolrw.c r_usb_pdriver.c r_usb_pintfifo.c r_usb_pinthandler_usbip0.c r_usb_plibusbip.c r_usb_psignal.c r_usb_pstdfunction.c r_usb_pstdrequest.c
    rz/fsp/src/r_usb_basic/src/hw/: r_usb_creg_abs.c r_usb_creg_access.c r_usb_dma_control_rz.c r_usb_dma_control_rz_target.c r_usb_dma_rz.c r_usb_hostelectrical.c r_usb_hreg_abs.c r_usb_hreg_access.c r_usb_mcu.c r_usb_preg_abs.c r_usb_preg_access.c
    rz/fsp/src/r_usb_hmsc/: r_usb_hmsc.c
    rz/fsp/src/r_usb_hmsc/src/: r_usb_hmsc_driver.c r_usb_hstorage_driver.c
    rz/fsp/src/r_usb_hmsc/src/inc/: r_usb_hmsc_driver.h
    rz/fsp/src/rm_block_media_usb/: rm_block_media_usb.c
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
    rz/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c system_core.c
  group Flex Software/Generated Data
    rz_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: common_utils.h FreeRTOSConfig.h hal_entry.c hmsc_baremetal_apl.c sio_char.h siochar.c siorw.c
